# Keil uVision project send.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W104 STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: send +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC
  group Source Group 1
    ./: STARTUP.A51
  group SRC
    ../SRC/: CMT2300test.c delay.c
